# Keil uVision project car.uvprojx, settings and files
target car (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: CPUTYPE("Cortex-M0")
  output: car +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --split_sections -D__ASSERT_MSG -DTARGET_STM32F0 --no_rtti -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M0 -D__CORTEX_M0 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DTRANSACTION_QUEUE_SIZE_SPI=2 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_NUCLEO_F070RB -DMBED_BUILD_TIMESTAMP=1493207624.41 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTARGET_STM32F070RB -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed-dev; mbed-dev/cmsis; mbed-dev/drivers; mbed-dev/hal; mbed-dev/hal/storage_abstraction; mbed-dev/platform; mbed-dev/targets; mbed-dev/targets/TARGET_STM; mbed-dev/targets/TARGET_STM/TARGET_STM32F0; mbed-dev/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB; mbed-dev/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/device; mbed-dev/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/device/TOOLCHAIN_ARM_STD; mbed-dev/targets/TARGET_STM/TARGET_STM32F0/device
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DARM_MATH_CM0
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000100 size 0x3f00
  scatter file: mbed-dev/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/device/TOOLCHAIN_ARM_STD/stm32f070xb.sct
  group car
    ./: mbed_config.h
    ./: main.cpp
  group mbed-dev
    mbed-dev/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.cpp Ethernet.h FileBase.cpp FileBase.h FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemLike.cpp FileSystemLike.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LocalFileSystem.cpp LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Stream.cpp Stream.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F0/: analogin_api.c analogout_api.c can_device.h common_objects.h device.h gpio_irq_device.c gpio_irq_device.h i2c_device.h mbed_overrides.c pin_device.h pwmout_device.c pwmout_device.h serial_api.c spi_api.c
    mbed-dev/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-dev/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed-dev/platform/: Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed-dev/targets/TARGET_STM/: can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_rtx.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c rtc_api.c rtc_api_hal.h sleep.c stm_spi_api.c trng_api.c us_ticker_16b.c us_ticker_32b.c
    mbed-dev/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/device/: cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.h stm32f070xb.h stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
    mbed-dev/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-dev/: mbed.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/: objects.h PeripheralNames.h PeripheralPins.c PinNames.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/device/TOOLCHAIN_ARM_STD/: startup_stm32f070xb.S sys.cpp
    mbed-dev/targets/TARGET_STM/TARGET_STM32F0/device/: stm32_hal_legacy.h stm32f0xx_hal.c stm32f0xx_hal.h stm32f0xx_hal_adc.c stm32f0xx_hal_adc.h stm32f0xx_hal_adc_ex.c stm32f0xx_hal_adc_ex.h stm32f0xx_hal_can.c stm32f0xx_hal_can.h stm32f0xx_hal_cec.c stm32f0xx_hal_cec.h stm32f0xx_hal_comp.c stm32f0xx_hal_comp.h stm32f0xx_hal_conf.h stm32f0xx_hal_cortex.c stm32f0xx_hal_cortex.h stm32f0xx_hal_crc.c stm32f0xx_hal_crc.h stm32f0xx_hal_crc_ex.c stm32f0xx_hal_crc_ex.h stm32f0xx_hal_dac.c stm32f0xx_hal_dac.h stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dac_ex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.c stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_flash.c stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.c stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.c stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_i2s.c stm32f0xx_hal_i2s.h stm32f0xx_hal_irda.c stm32f0xx_hal_irda.h stm32f0xx_hal_irda_ex.h stm32f0xx_hal_iwdg.c stm32f0xx_hal_iwdg.h stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd.h stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pcd_ex.h stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc.h stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_rtc_ex.h stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard.h stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smartcard_ex.h stm32f0xx_hal_smbus.c stm32f0xx_hal_smbus.h stm32f0xx_hal_spi.c stm32f0xx_hal_spi.h stm32f0xx_hal_spi_ex.c stm32f0xx_hal_spi_ex.h stm32f0xx_hal_tim.c stm32f0xx_hal_tim.h stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tim_ex.h stm32f0xx_hal_tsc.c stm32f0xx_hal_tsc.h stm32f0xx_hal_uart.c stm32f0xx_hal_uart.h stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart_ex.h stm32f0xx_hal_usart.c stm32f0xx_hal_usart.h stm32f0xx_hal_usart_ex.h stm32f0xx_hal_wwdg.c stm32f0xx_hal_wwdg.h stm32f0xx_ll_adc.c stm32f0xx_ll_adc.h stm32f0xx_ll_bus.h stm32f0xx_ll_comp.c stm32f0xx_ll_comp.h stm32f0xx_ll_cortex.h stm32f0xx_ll_crc.c stm32f0xx_ll_crc.h stm32f0xx_ll_crs.c stm32f0xx_ll_crs.h stm32f0xx_ll_dac.c stm32f0xx_ll_dac.h stm32f0xx_ll_dma.c stm32f0xx_ll_dma.h stm32f0xx_ll_exti.c stm32f0xx_ll_exti.h stm32f0xx_ll_gpio.c stm32f0xx_ll_gpio.h stm32f0xx_ll_i2c.c stm32f0xx_ll_i2c.h stm32f0xx_ll_iwdg.h stm32f0xx_ll_pwr.c stm32f0xx_ll_pwr.h stm32f0xx_ll_rcc.c stm32f0xx_ll_rcc.h stm32f0xx_ll_rtc.c stm32f0xx_ll_rtc.h stm32f0xx_ll_spi.c stm32f0xx_ll_spi.h stm32f0xx_ll_system.h stm32f0xx_ll_tim.c stm32f0xx_ll_tim.h stm32f0xx_ll_usart.c stm32f0xx_ll_usart.h stm32f0xx_ll_utils.c stm32f0xx_ll_utils.h stm32f0xx_ll_wwdg.h
  group odev_line_sensor
    ./: odev_line_sensor.h odev_line_sensor.cpp
  group odev_motor
    ./: odev_motor.h odev_motor.cpp
  group odev_sound
    ./: odev_sound.h odev_sound.cpp
  group odev_ultrasonic_sensor
    ./: odev_ultrasonic_sensor.h odev_ultrasonic_sensor.cpp
  group odev_matrix_led
    ./: odev_matrix_led.cpp odev_matrix_led.h
  group odev_power
    ./: odev_power_manage.h odev_power_manage.cpp
  group odev_command
    ./: odev_command.cpp odev_command.h
  group odev_extend
    ./: odev_extend.h odev_extend.cpp
  group odev_motion
    ./: odev_motion.cpp odev_motion.h
  group odev_action
    ./: odev_action.cpp odev_action.h
  group odev_buzzer
    ./: odev_buzzer.cpp odev_buzzer.h
  group odev_extend_throw
    ./: odev_extend_throw.cpp odev_extend_throw.h
  group odev_extend_temp
    ./: odev_extend_temp.h odev_extend_temp.cpp
  group odev_extend_light
    ./: odev_extend_light.h odev_extend_light.cpp
  group odev_extend_sound
    ./: odev_extend_sound.cpp odev_extend_sound.h
  group odev_extend_motion
    ./: odev_extend_motion.cpp odev_extend_motion.h
  group odev_extend_flame
    ./: odev_extend_flame.cpp odev_extend_flame.h
  group odev_extend_gas
    ./: odev_extend_gas.cpp odev_extend_gas.h
  group odev_extend_seg
    ./: odev_extend_7seg_display.cpp odev_extend_7seg_display.h
  group odev_flash
    ./: eeprom.cpp eeprom.h
  group odev_ticker
    ./: odev_myticker.cpp odev_myticker.h
